# Keil uVision project HDH_YKQ_SPJ.uvprojx, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./common/src/: startup_LPC17xx.s
  group System Code
    ./common/src/: system_LPC17xx.c
  group Source Code
    ./Src/: timer.c can.c main.c CanOpen.c adc.c GPIO.c i2c.c uart.c App_IO.c App_Bus.c Task.c App_usr.c i2c2.c App_DGUS.c App_lcd.c TEA.c App_Comm.c wl.c
  group Documentation
    ./: Abstract.txt
    ./Src/: config.h
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1764 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x4000) IRAM2(0x2007C000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HNGL_ZYJ_L4X_119T +hex
  AfterMake: fromelf.exe --bincombined --bincombined_base=0x000 --bincombined_padding=1,0 --output="$L..\out\@L.bin" "#L"
  AfterMake: "$L..\out\rename.bat" "$L..\out\@L.bin"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c include: .\common\inc;.\Src
  asm include: ..\common\inc
  memory RVCT4: ROM 0x2000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
software components: CMSIS:CORE 5.2.0
